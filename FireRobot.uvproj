# Keil uVision project FireRobot.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: FireRobot +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\motor;.\trace;.\fireSensor
  group Source Group 1
    ./: STARTUP.A51 main.c
  group motor
    ./motor/: motor.c motor.h
  group trace
    ./trace/: trace.h trace.c
  group firesensor
    ./fireSensor/: firesensor.c firesensor.h
